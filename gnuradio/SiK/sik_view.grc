options:
  parameters:
    author: Eric Miers
    description: View the Frequency Spectrum of SiK - Used to help hone in on a channel for data capture
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: SiK Frequency Spectrum Viewer
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    orient: Qt.Horizontal
    start: '-50'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2*bandwidth
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: 890e6
    step: bandwidth
    stop: 940e6
    value: 917e6
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: bandwidth
    fc: tuning
    fftsize: '2048'
    name: '"Frequency Visualizer"'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: bandwidth
    center_freq0: tuning
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: '"serial=307D1D5"'
    dev_args: '""'
    gain0: rf_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
